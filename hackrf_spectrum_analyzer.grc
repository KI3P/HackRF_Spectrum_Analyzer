options:
  parameters:
    author: Oliver KI3P
    category: Custom
    description: Working with the USRP!
    generate_options: qt_gui
    id: spectrum_analyzer
    output_language: python
  states: {}

blocks:
- name: f_tx_MHz
  id: variable_qtgui_range
  parameters:
    label: Tune frequency [MHz]
    start: '35'
    step: '10'
    stop: '4400'
    value: '146'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: 65536*8
  states: {}
- name: fft_rate
  id: variable
  parameters:
    value: (1/samp_rate) * (fft_len)
  states: {}
- name: freq
  id: variable
  parameters:
    value: f_tx_MHz*1000000-200000
  states: {}
- name: passband
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '512'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_len
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '50'
    max_iter: '4000'
    scale: 1/50
    type: float
    vlen: fft_len
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_len
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_len
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: int
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, vectorSize=65536*8):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Max and argmax',   # will show up in GRC
                  in_sig=[(np.float32,vectorSize)],
                  out_sig=[np.int32, np.float32]
              )

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              #print("Type input_items[0] = " + repr(type(input_items[0])))
              # ndarray
              #print("Type input_items[0][0] = " + repr(type(input_items[0][0])))
              # ndarray
              #print("Len input_items[0][0] = " + repr(len(input_items[0][0])))
              # 524288
              for vectorIndex in range(len(input_items[0])):
                  d = input_items[0][vectorIndex]
                  I = np.argmax(d)
                  output_items[0][vectorIndex] = I
                  output_items[1][vectorIndex] = d[I]
              return len(output_items[0])
    vectorSize: fft_len
  states: {}
- name: f_tx_MHz
  id: parameter
  parameters:
    type: eng_float
    value: '146'
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_len)
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: f_tx_MHz
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.band_pass(1.0,samp_rate,f_tx_MHz-freq-passband/2,f_tx_MHz-freq+passband/2,400)
    type: ccc
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: (freq-samp_rate/2)/1e6
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: ~15.25 updates / second
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0,bias=0
    bb_gain0: '10'
    freq0: freq
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: '16'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    vlen: fft_len
    x_axis_label: '"Frequency [MHz"'
    x_start: (freq-samp_rate/2)/1e6
    x_step: (samp_rate/fft_len)/1e6
    y_axis_label: '"Power"'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '18080'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:55555
    timeout: '100'
    type: float
    vlen: fft_len
  states: {}
- name: zeromq_pub_sink_1
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5000
    timeout: '100'
    type: int
    vlen: vec_len
  states: {}
- name: zeromq_pub_sink_1_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5001
    timeout: '100'
    type: float
    vlen: vec_len
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_nlog10_ff_0, '0', zeromq_pub_sink_0, '0']
- [blocks_nlog10_ff_0_0, '0', epy_block_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', zeromq_pub_sink_1, '0']
- [blocks_stream_to_vector_1_0, '0', zeromq_pub_sink_1_0, '0']
- [epy_block_0, '0', blocks_stream_to_vector_1, '0']
- [epy_block_0, '1', blocks_stream_to_vector_1_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_stream_to_vector_0, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
